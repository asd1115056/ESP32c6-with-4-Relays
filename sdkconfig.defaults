## sdkconfig.defaults
```kconfig
CONFIG_ESP_PROTOCOMM_SUPPORT_SECURITY_VERSION_1=y
CONFIG_PARTITION_TABLE_SINGLE_APP_LARGE=y
```
